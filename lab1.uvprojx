# Keil uVision project lab1.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: global.h MAG3110.h MAG3110.c I2C.h I2C.c GPIO.h GPIO.c Timer.h Timer.c main.c LCD.h LCD.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0, CMSIS:NN Lib 5.0.0, Device:Startup 1.0.0
